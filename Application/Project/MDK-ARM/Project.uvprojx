# Keil uVision project Project.uvprojx, settings and files
target STM32F429-Discovery (6160000::V6.16::ARMCLANG)
  device: STM32F429ZIYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-STM32F429-Discovery +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=4 wLevel=3
  c define: USE_HAL_DRIVER STM32F429xx USE_STM32F429I_DISCO HSE_VALUE=8000000 EW_USE_FREE_RTOS=1
  c include: ../Inc;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Inc;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/BSP/STM32F429I-Discovery;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/BSP/Components;..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers/CMSIS/Include;..\..\..\TargetSpecific;..\..\GeneratedCode;..\..\Source;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\include;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32429I-DISCOVERY
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery_io.c stm32f429i_discovery.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/ili9341/: ili9341.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_graphics.c ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_system.c ew_bsp_touch.c stm32f4xx_it.c system_stm32f4xx.c
  group EmWi/Application
    ./: startup_stm32f429xx.s
    ../../Source/: main.c DeviceDriver.c ewmain.c ewconfig.h led.c
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
